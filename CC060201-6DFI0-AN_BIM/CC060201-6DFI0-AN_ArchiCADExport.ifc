Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView_V2.0]
File name: 0001
Time: 2025-01-13T08:30:04
Written by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013
Made in: 21.1.1.109 - Exporter 21.1.1.109 - Alternate UI 21.1.1.109
Comment: STEP Physical File produced by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013 * Module: EDMstepFileFactory/EDMstandAlone * Creation date: Mon Jan 13 08:30:04 2025 * Host: DESKTOP-EKL9I0B * Database: C:\Users\WINDOW~1\AppData\Local\Temp\416dd539-3432-4963-86f7-dc902053cc6c\2162908c-0283-4bd6-9c2c-5ac38a7dfb33\ifc * Database version: 5507 * Database creation date: Mon Jan 13 08:30:03 2025 * Schema: IFC2X3 * Model: DataRepository.ifc * Model creation date: Mon Jan 13 08:30:04 2025 * Header model: DataRepository.ifc_HeaderModel * Header model creation date: Mon Jan 13 08:30:04 2025 * EDMuser: sdai-user * EDMgroup: sdai-group * License ID and type: 5605 : Permanent license. Expiry date: * EDMstepFileFactory options: 020000

# IfcProject, 0001
LongName: Project Name; Phase: Project Status

# IfcSite, Default
RefLatitude: 42, 21, 31, 181945; RefLongitude: -71, -3, -24, -263305; RefElevation: 0 mm
Pset_ProductRequirements - Category: Project Information

# IfcBuilding
Pset_BuildingCommon - NumberOfStoreys: 1
Pset_ProductRequirements - Category: Project Information

# IfcBuildingStorey: Level:8mm Head, Level 1
LongName: Level 1; Elevation: 0 mm
Pset_AirSideSystemInformation - Name: Level 1
Pset_ProductRequirements - Name: Level 1; Category: Levels

# IfcDistributionPort (2)
Description: Flow
Name | FlowDirection
Port_370125 | SOURCE
Port_370125 | SINK

# IfcFlowTerminal: Sanitary_Toilets_INAX_Close Couple Toilet_CC060203-6DFI0-AN:CC060203-6DFI0-AN-S200 CC Touchless Toilet (Indonesia), Sanitary_Toilets_INAX_Close Couple Toilet_CC060203-6DFI0-AN:CC060203-6DFI0-AN-S200 CC Touchless Toilet (Indonesia):370125
In: Level 1
Type - Material: INAX - Vitreous China - BW1
Type - Pset_ElectricalDeviceCommon - NumberOfPoles: 1
Type - Pset_ManufacturerTypeInformation - Manufacturer: INAX
Type - Pset_ProductRequirements - Category: Plumbing Fixtures
Type - Pset_QuantityTakeOff - Reference: CC060203-6DFI0-AN-S200 CC Touchless Toilet (Indonesia)
Material: INAX - Vitreous China - BW1, INAX - Plastic
Pset_DistributionFlowElementCommon - Reference: CC060203-6DFI0-AN-S200 CC Touchless Toilet (Indonesia); sets with these values: 2
